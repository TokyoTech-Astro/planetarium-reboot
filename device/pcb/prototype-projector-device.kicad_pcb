# Repository TokyoTech-Astro/planetarium-reboot

File README.md:

# Projector Prototype

投影筒まわりを新しくするための試作

## Concept

```mermaid
flowchart TB
  subgraph 構造球基板
    A(ルータ) --> |WiFi| B(マイコン)
    B --> |UART| C(RS485ドライバ)
  end

  subgraph 投影筒基板1
    D1(RS485ドライバ) --> |UART| E1(マイコン)
    E1 --> |PWM| F1(LEDドライバ)
    F1 --> G1(パワーLED)
  end

  subgraph 投影筒基板2
    D2(RS485ドライバ) --> |UART| E2(マイコン)
    E2 --> |PWM| F2(LEDドライバ)
    F2 --> G2(パワーLED)
  end

  構造球基板 --> |DMX| 投影筒基板1 --> |DMX| 投影筒基板2
```

## Device v0.1

- 動作確認とFirmware開発のために数個製作予定

## KiCad design device/pcb/prototype-projector-device.kicad_pcb

Parts:
C1, C3: 0.1u; C_0603_1608Metric
C2: 1u50V; C_0603_1608Metric
C4: 4.7u50V; C_0805_2012Metric
D1, D2: SS2040FL; D_SOD-123F
J1: LED; SolderWire-0.25sqmm_1x02_P4.2mm_D0.65mm_OD1.7mm_Relief
J2: Serial-UPDI; PinHeader_1x04_P2.54mm_Vertical
J3: UART; PinHeader_1x03_P2.54mm_Vertical
J4: DMX1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J5: DMX2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
L1: 68u; L_Taiyo-Yuden_NR-10050_9.8x10.0mm
R1: 0.1; R_1210_3225Metric
R2: 1k; R_0603_1608Metric
TP1: +24V; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP2: GND; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP3: +3.3V; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP4: ADJ; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: ATtiny202-SS; SOIC-8_3.9x4.9mm_P1.27mm
U2: NJM78L33SU3; SOT-89-3
U3: CL6808; SOT-89-5
U4: MAX3485; SOP-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C1.1, C3.1, J2.1, TP3.1, U1.1 (VCC), U2.1 (OUT), U4.8 (VCC)
+24V: C2.1, C4.1, D1.1 (K), J4.1, J5.1, R1.2, TP1.1, U2.3 (IN), U3.5 (VIN)
/LED_ADJ: TP4.1, U1.4 (PA1), U3.3 (ADJ)
/RS485_DE: U1.5 (PA2), U4.3 (DE)
/UART_RX: J3.2, U1.3 (PA7), U4.1 (RO)
/UART_TX: J3.1, U1.2 (PA6), U4.4 (DI)
/UPDI: R2.1, U1.6 (~RESET/PA0)
/~RS485_RE: U1.7 (PA3), U4.2 (~RE)
GND: C1.2, C2.2, C3.2, C4.2, J2.4, J3.3, J4.4, J5.4, TP2.1, U1.8 (GND), U2.2 (GND), U3.2 (GND), U4.5 (GND)
unnamed: D1.2 (A), L1.2, U3.1 (LX)
unnamed: D2.1 (K), J2.2
unnamed: D2.2 (A), J2.3, R2.2
unnamed: J1.1, R1.1, U3.4 (ISNS)
unnamed: J1.2, L1.1
unnamed: J4.2, J5.2, U4.6 (A)
unnamed: J4.3, J5.3, U4.7 (B)

Notes on the sheet:
Adapter TX
470が買いにくい
Adapter RX
1000mA @ RS = 0.1 for XPGWHT-L1
CATHODE
Fixed Stars Device Board
ANODE

Board: 2 copper layers, 40.0 x 35.0 mm, 22 parts (0 on the bottom side), 16 nets.

File device/pcb/version/v0.1.1/bom.xlsx:

Qty | Price | Reference(s) | Value | LibPart | Footprint | Datasheet
2 | 5 | C1, C3 | 0.1u | Device:C | Capacitor_SMD:C_0603_1608Metric | https://akizukidenshi.com/catalog/g/gP-13374/
1 | 10 | C2 | 1u50V | Device:C | Capacitor_SMD:C_0603_1608Metric | https://akizukidenshi.com/catalog/g/gP-15331/
1 | 8 | C4 | 4.7u50V | Device:C | Capacitor_SMD:C_0805_2012Metric | https://akizukidenshi.com/catalog/g/gP-13605/
2 | 30 | D1, D2 | SS2040FL | Device:D_Schottky | Diode_SMD:D_SOD-123F | https://akizukidenshi.com/catalog/g/gI-02073/
1 | 3.5 | J2 | Serial-UPDI | Connector_Generic:Conn_01x04 | Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical | https://akizukidenshi.com/catalog/g/gC-00167/
1 | 10 | J4, J5 | DMX1, DMX2 | Connector_Generic:Conn_01x04 | Connector_JST:JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical | https://akizukidenshi.com/catalog/g/gC-12249/
1 | 60 | L1 | 68u | Device:L | Inductor_SMD:L_Taiyo-Yuden_NR-10050_9.8x10.0mm | https://akizukidenshi.com/catalog/g/gP-08323/
1 | 10 | R1 | 0.1 | Device:R | Resistor_SMD:R_1210_3225Metric | https://akizukidenshi.com/catalog/g/gR-10822/
1 | 20 | R2 | 1k | Device:R | Resistor_SMD:R_0603_1608Metric | https://akizukidenshi.com/catalog/g/gR-11790/
1 | 60 | U1 | ATtiny202-SS | MCU_Microchip_ATtiny:ATtiny202-SS | Package_SO:SOIC-8_3.9x4.9mm_P1.27mm | https://akizukidenshi.com/catalog/g/gI-15731/
1 | 20 | U2 | NJM78L33SU3 | Regulator_Linear:L78L33_SOT89 | Package_TO_SOT_SMD:SOT-89-3 | https://akizukidenshi.com/catalog/g/gI-11319/
1 | 50 | U3 | CL6808 | CL6808:CL6808 | Package_TO_SOT_SMD:SOT-89-5 | https://akizukidenshi.com/catalog/g/gI-06278/
1 | 70 | U4 | MAX3485 | Interface_UART:MAX3485 | Package_SO:SOP-8_3.9x4.9mm_P1.27mm | https://akizukidenshi.com/catalog/g/gI-16211/
 | 356.5

## Commit log

2022-11-03 modify: README
2022-11-03 add: 昔の資料
2022-11-03 fix: README
2022-11-03 add: 投影筒の試作に関するdoc
2022-11-03 modify: docsに参考サイトを追記
2022-11-03 modify: doc
2022-11-03 fix: doc
2022-11-04 add: remake-projectorへのリンク
2022-11-04 fix: リンク
2022-11-05 modify: 主な部品
2022-11-05 add: 回路図調整
2022-11-05 fix: 図
2022-11-05 add: 他リポジトリへの参照を追加
2022-11-05 modify: LEDの情報
2022-11-05 add: 配線
2022-11-05 add: v0.1 出力
2022-11-05 add: wikiページの情報
2022-11-05 add: とりあえずの回路図
2022-11-05 fix: URL
2022-11-05 modify: 試作専用のリポジトリに変更
2022-11-11 modify: 24V駆動対応 v0.1.1
